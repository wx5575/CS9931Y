# Keil uVision project spi_cpld.uvproj, settings and files
target STM32f407 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: spi_cpld
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\bsp\drivers\inc;.\bsp\drivers\inc;.\bsp\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\bsp\Libraries\CMSIS\Include;.\bsp\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./applications/: startup.c
  group Drivers
    ./bsp/drivers/: board.c stm32f4xx_it.c spi_cpld.c
    ./bsp/drivers/src/: bsp_led.c
  group STM407_StdPeriph
    ./bsp/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CORTEX-M4
    ./bsp/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./bsp/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
