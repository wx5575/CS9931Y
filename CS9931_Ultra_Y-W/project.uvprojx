# Keil uVision project project.uvprojx, settings and files
target STM32f407 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PROGRAM +hex
  AfterMake: fromelf.exe --bin -o ./烧录文件/PROGRAM.BIN  ../buildoutput/output/PROGRAM.axf
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: .\BSP\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\BSP\Libraries\CMSIS\ST\STM32F4xx\Include;.\BSP\drivers;.\OS\rtthread;.\OS\rtthread\include;.\OS\rtthread\libcpu\arm\common;.\OS\rtthread\libcpu\arm\cortex-m4;.\OS\rtthread\components\CMSIS\Include;.\OS\rtthread\components\drivers\include;.\OS\rtthread\components\finsh;.\OS\rtthread\components\init;.\applications;.\applications\UI;.\BSP\drivers\inc;.\OS\rtthread\components\rtgui\include;.\OS\rtthread\components\rtgui\server;.\image;.\OS\rtthread\components\dfs\include;.\Drivers;.\Test_Main;.\applications\UI\SUI\inc;.\BSP\drivers\CH376\inc;.\BSP\drivers\USBhost;.\Drivers\port;.\SCPI;.\BSP\ZWD414B;.\JJ98;.\OS\rtthread\components\rtgui\common
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Application
    ./applications/: application.c startup.c CS99xx.c CS9931_Config.c CS9931_Config.h
  group Drivers
    ./BSP/drivers/: board.c stm32f4xx_it.c usart.c bsp_button.c RA8875.c spi_flash.c memory.c memorymanagement.c rtc.c bmp.c bsp_font.c bsp_text.c bsp_listbox.c bsp_ico.c bsp_graph.c Usart1.c
    ./BSP/drivers/src/: bsp_sdio_sd.c
  group Drivers-ch376
    ./BSP/drivers/CH376/src/: CH376_USB_UI.C FILE_SYS.C HAL_BASE.C SPI_SW.C
  group STM407_StdPeriph
    ./BSP/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./BSP/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./BSP/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Kernel
    ./OS/rtthread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ./OS/rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ./OS/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ./OS/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
    ./BSP/drivers/: serial.c
  group finsh
    ./OS/rtthread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Filesystem
    ./OS/rtthread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ./OS/rtthread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group UI-APP
    ./applications/UI/: ui_application.c ui_title.c ui_menu.c ui_home.c ui_status.c ui_file.c ui_step.c ui_system.c ui_result.c ui_help.c ui_about.c ui_display.c ui_file_Port.c ui_autocal.c
  group SUI
    ./applications/UI/SUI/: readme.txt
    ./applications/UI/SUI/src/: sui_window.c sui_drivers.c sui_color.c
  group font
    ./OS/rtthread/components/rtgui/common/: asc16font.c hz16font.c asc20font.c hz20font.c asc24font.c hz24font.c asc32font.c hz32font.c
  group Drivers
    ./Drivers/: AD_DA.c AD_DA.h driver.h Key_LED.c Key_LED.h Multiplexer.c Multiplexer.h Relay.c Relay.h Self_Test.c Self_Test.h spi_cpld.c spi_cpld.h PLC.c
  group Test_Sched
    ./Test_Main/: ACW_Routine.c ACW_Routine.h DCW_Routine.c DCW_Routine.h GR_Routine.c GR_Routine.h LC_Routine.c LC_Routine.h GR.c GR.h LC.c LC.h Output_Control.c Output_Control.h Relay_Change.c Relay_Change.h Test_Main.c Test_Sched.c Test_Sched.h Cal.c Cal.h ACW_GR_Routine.c DCW_GR_Routine.c PW_Routine.c IR_Routine.c IR.c IR.h
  group SCPI
    ./SCPI/: API_Sched.c communication.c CS9931CInstructionTable.c library.c scpi_parser.c scpiInstruction.c
  group ZWD414B
    ./BSP/ZWD414B/: ModBus.c systick.c zwd414b.c zwd414b_tools.c
  group logo
    ./logo/: elitech_custom_logo.c
  group JJ98
    ./JJ98/: jj98.c
